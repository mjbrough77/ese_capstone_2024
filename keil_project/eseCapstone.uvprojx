# Keil uVision project eseCapstone.uvprojx, settings and files
target STM32F103RB (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: eseCapstone
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=2
  c misc: -Wno-invalid-utf8
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: main.c clocks_ese.c i2c_ese.c interrupts_ese.c gpio_ese.c mpu6050_driver.c usart_ese.c timers_ese.c
  group include
    ./include/: clocks_ese.h i2c_ese.h interrupts_ese.h gpio_ese.h mpu6050_driver.h timers_ese.h usart_ese.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
